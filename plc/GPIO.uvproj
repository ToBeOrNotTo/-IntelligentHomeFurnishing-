# Keil uVision project GPIO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GPIO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\devices;.\hardware\RGB_LED;.\system;.\hardware\TP4115;.\hardware\WS2812B;.\hardware\debug-usart;.\hardware\CO2;.\hardware\USART3;.\hardware\myiic;.\hardware\SHT20;.\hardware\BH1750;.\hardware\zigbee_usart;.\hardware\VEML6070
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: main.c
  group boot
    ./boot/: startup_stm32f10x_md.s
  group devices
    ./devices/: delay.c sys.c Tim.c
  group hardware
    ./hardware/RGB_LED/: rgb_led.c
    ./hardware/A4988/: A4988.c
    ./hardware/TP4115/: TP4115.c
    ./hardware/WS2812B/: WS2812B.c
    ./hardware/debug-usart/: Debug_usart.c
    ./hardware/CO2/: CO2.c
    ./hardware/USART3/: usart3.c
    ./hardware/myiic/: myiic.c
    ./hardware/SHT20/: SHT20.c
    ./hardware/BH1750/: BH1750.c
    ./hardware/zigbee_usart/: ZigBee_usart.c
    ./hardware/VEML6070/: veml6070.c
  group system
    ./system/: jpstm32_exti.c jpstm32_gpio.c jpstm32_nvic.c jpstm32_sysclk.c
